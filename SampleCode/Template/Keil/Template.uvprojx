# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M2003XC1AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.7
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: Template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M2003\Include;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M2003.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M2003/Source/ARM/: startup_M2003.s
    ../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c timer.c fmc.c
  group User
    ../: main.c misc_config.c timer_service.c EEPROM_Emulate.c
